## 上课/操作系统安全/实验2/security/youho/Kconfig
```kconfig
config     SECURITY_YOUHO
   bool     "youho support"
   depends on SECURITY
   default     n
   help
     introduction of youho modules
```
